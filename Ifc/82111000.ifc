Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Roger_prio1\Arbetsmapp\82111000\AutoCAD Architecture\82111000.ifc
Time: 2014-02-27T09:16:43
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 82111000
LongName: 82111000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 82111000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 82111000, BUILDINGELEMENTPROXY(1)
In: 82111000
Description: FM Mattsson 82111000, Safety mixer f/ Shower 9000E II 160 c/c chrome, upward outlet
